# Keil uVision project dsp_for_lpc553x_using_pq.uvprojx, settings and files
target dsp_for_lpc553x_using_pq (6190000::V6.19::ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: hello_world.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_LPC55S36JBD100, MCUXPRESSO_SDK
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/LPC55S36/utilities/str;../../../../../devices/LPC55S36/utilities/debug_console_lite;../../../../../devices/LPC55S36/drivers;../../../../../devices/LPC55S36;../../../../../components/uart;../../../../../components/lists;..\..\..\..\..\CMSIS\Core\Include;..\source;..\..\..\..\..\devices\LPC55S36\drivers\flash;..\..\..\..\..\CMSIS\DSP\Include;..\..\..\..\..\CMSIS\DSP\PrivateInclude
  asm define: CPU_LPC55S36JBD100, DEBUG,__CC_ARM,KEIL, DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S36_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../source/: hardware_init.c lcd.c lcd_fonts.c lcd_hx8347d.c main.c task_lcd_display.c task_pq_fft_128.c task_pq_fft_256.c task_pq_fft_512.c task_pq_fir.c task_pq_mat_add.c task_pq_mat_inv.c task_pq_mat_mul.c task_pq_recods.c task_user_key.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group utilities
    ../../../../../devices/LPC55S36/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../devices/LPC55S36/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group drivers
    ../../../../../devices/LPC55S36/drivers/: fsl_iocon.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_gpio.h fsl_gpio.c fsl_flexspi.c fsl_flexspi_dma.c fsl_spi.c fsl_spi_dma.c fsl_powerquad_basic.c fsl_powerquad_cmsis.c fsl_powerquad_data.c fsl_powerquad_filter.c fsl_powerquad_math.c fsl_powerquad_matrix.c fsl_powerquad_transform.c fsl_pint.c fsl_inputmux.c fsl_dma.c
    ../../../../../devices/LPC55S36/drivers/flash/src/: fsl_flash.c
  group device
    ../../../../../devices/LPC55S36/: fsl_device_registers.h LPC55S36.h LPC55S36_features.h system_LPC55S36.c system_LPC55S36.h
  group startup
    ../../../../../devices/LPC55S36/arm/: startup_LPC55S36.S
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
    ../../../../../CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
